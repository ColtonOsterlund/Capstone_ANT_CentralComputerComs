# Keil uVision project demo_gateway.uvprojx, settings and files
target standalone (ARM-ADS)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.12.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(64000000) ELITTLE
  output: demo_gateway +hex
  c flags: Optim=1 uC99=1
  c define: STANDALONE ANT_STACK_SUPPORT_REQD NRF52832 S332 BOARD_CUSTOM NRF52 SOFTDEVICE_PRESENT SWI_DISABLE0 CONFIG_GPIO_AS_PINRESET
  c misc: --diag_suppress=1296
  c include: ..\inc;..\config;..\..\..\inc;..\..\..\nrf5_sdk\components\ant\ant_channel_config;..\..\..\nrf5_sdk\components\ant\ant_search_config;..\..\..\nrf5_sdk\components\ant\ant_stack_config;..\..\..\nrf5_sdk\components\drivers_nrf\common;..\..\..\nrf5_sdk\components\drivers_nrf\config;..\..\..\nrf5_sdk\components\drivers_nrf\delay;..\..\..\nrf5_sdk\components\drivers_nrf\gpiote;..\..\..\nrf5_sdk\components\drivers_nrf\hal;..\..\..\nrf5_sdk\components\libraries\button;..\..\..\nrf5_sdk\components\libraries\scheduler;..\..\..\nrf5_sdk\components\libraries\timer;..\..\..\nrf5_sdk\components\libraries\util;..\..\..\nrf5_sdk\components\libraries\log;..\..\..\nrf5_sdk\components\libraries\log\src;..\..\..\nrf5_sdk\components\libraries\strerror;..\..\..\nrf5_sdk\components\libraries\bsp;..\..\..\nrf5_sdk\components\boards;..\..\..\nrf5_sdk\components\softdevice\common\softdevice_handler;..\..\..\nrf5_sdk\components\toolchain;..\..\..\nrf5_sdk\external\segger_rtt;..\..\..\nrf5_sdk\components\softdevice\s332\headers;..\..\..\nrf5_sdk\components\softdevice\s332\headers\nrf52
  asm define: ANT_STACK_SUPPORT_REQD DEBUG S332 BOARD_CUSTOM CONFIG_GPIO_AS_PINRESET NRF52 SOFTDEVICE_PRESENT SWI_DISABLE0
  asm misc: --cpreproc
  memory RVCT4: ROM 0x29000 size 0x57000
  memory RVCT9: RAM 0x20001e30 size 0xe1d0
  group Application
    ../src/: main.c
  group Board Support
    ../../../nrf5_sdk/components/libraries/bsp/: bsp.c
    ../../../nrf5_sdk/components/boards/: boards.c
  group Documentation
    ../../: license.txt
  group ANT_BLAZE
    ../../../bin/: ANT_BLAZE_Gateway_Library_Keil.lib
  group nRF_ANT
    ../../../nrf5_sdk/components/ant/ant_stack_config/: ant_stack_config.c
  group nRF_Drivers
    ../../../nrf5_sdk/components/drivers_nrf/common/: nrf_drv_common.c
    ../../../nrf5_sdk/components/drivers_nrf/gpiote/: nrf_drv_gpiote.c
  group nRF_Libraries
    ../../../nrf5_sdk/components/libraries/button/: app_button.c
    ../../../nrf5_sdk/components/libraries/util/: app_error.c app_util_platform.c nrf_assert.c app_error_weak.c
    ../../../nrf5_sdk/components/libraries/timer/: app_timer.c
    ../../../nrf5_sdk/components/libraries/hardfault/nrf52/handler/: hardfault_handler_keil.c
    ../../../nrf5_sdk/components/libraries/hardfault/: hardfault_implementation.c
  group nRF_Log
    ../../../nrf5_sdk/components/libraries/log/src/: nrf_log_backend_serial.c nrf_log_frontend.c
    ../../../nrf5_sdk/external/segger_rtt/: RTT_Syscalls_KEIL.c SEGGER_RTT.c SEGGER_RTT_printf.c
software components: CMSIS:CORE 4.3.0, Device:Startup 8.5.0
