# IAR project demo_gateway.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: nrf52832_xxaa nRF52832_xxAA
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ANT_STACK_SUPPORT_REQD; NRF52832; S332; BOARD_CUSTOM; NRF52; SOFTDEVICE_PRESENT; SWI_DISABLE0; DEBUG; CONFIG_GPIO_AS_PINRESET
  ICCARM.CCIncludePath2: ..\inc; ..\config; ..\..\..\inc; ..\..\..\nrf5_sdk\components\ant\ant_channel_config; ..\..\..\nrf5_sdk\components\ant\ant_search_config; ..\..\..\nrf5_sdk\components\ant\ant_stack_config; ..\..\..\nrf5_sdk\components\drivers_nrf\common; ..\..\..\nrf5_sdk\components\drivers_nrf\delay; ..\..\..\nrf5_sdk\components\drivers_nrf\gpiote; ..\..\..\nrf5_sdk\components\drivers_nrf\hal; ..\..\..\nrf5_sdk\components\libraries\button; ..\..\..\nrf5_sdk\components\libraries\scheduler; ..\..\..\nrf5_sdk\components\libraries\timer; ..\..\..\nrf5_sdk\components\libraries\util; ..\..\..\nrf5_sdk\components\libraries\log; ..\..\..\nrf5_sdk\components\libraries\log\src; ..\..\..\nrf5_sdk\components\softdevice\common\softdevice_handler; ..\..\..\nrf5_sdk\components\toolchain; ..\..\..\nrf5_sdk\external\segger_rtt; ..\..\..\nrf5_sdk\components\softdevice\s332\headers; ..\..\..\nrf5_sdk\components\softdevice\s332\headers\nrf52; ..\..\..\nrf5_sdk\components\device; ..\..\..\nrf5_sdk\components\toolchain\CMSIS\Include; ..\..\..\nrf5_sdk\components\toolchain; ..\..\..\nrf5_sdk\components\libraries\strerror; ..\..\..\nrf5_sdk\components\libraries\bsp; ..\..\..\nrf5_sdk\components\boards
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: demo_gateway.hex
  ILINK.IlinkOutputFile: demo_gateway.out
  ILINK.IlinkIcfFile: demo_gateway.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: ANT_STACK_SUPPORT_REQD; NRF52832; S332; BOARD_CUSTOM; NRF52; SOFTDEVICE_PRESENT; SWI_DISABLE0; CONFIG_GPIO_AS_PINRESET
  ICCARM.CCIncludePath2: ..\inc; ..\config; ..\..\..\inc; ..\..\..\ant_device_firmware_update\include; ..\..\..\nrf5_sdk\components\ant\ant_channel_config; ..\..\..\nrf5_sdk\components\ant\ant_search_config; ..\..\..\nrf5_sdk\components\ant\ant_stack_config; ..\..\..\nrf5_sdk\components\drivers_nrf\common; ..\..\..\nrf5_sdk\components\drivers_nrf\delay; ..\..\..\nrf5_sdk\components\drivers_nrf\gpiote; ..\..\..\nrf5_sdk\components\drivers_nrf\hal; ..\..\..\nrf5_sdk\components\libraries\button; ..\..\..\nrf5_sdk\components\libraries\scheduler; ..\..\..\nrf5_sdk\components\libraries\timer; ..\..\..\nrf5_sdk\components\libraries\util; ..\..\..\nrf5_sdk\components\libraries\log; ..\..\..\nrf5_sdk\components\libraries\log\src; ..\..\..\nrf5_sdk\components\softdevice\common\softdevice_handler; ..\..\..\nrf5_sdk\components\toolchain; ..\..\..\nrf5_sdk\examples\bsp; ..\..\..\nrf5_sdk\external\segger_rtt; ..\..\..\nrf5_sdk\components\softdevice\s332\headers; ..\..\..\nrf5_sdk\components\softdevice\s332\headers\nrf52; ..\..\..\nrf5_sdk\components\device; ..\..\..\nrf5_sdk\components\toolchain\CMSIS\Include; ..\..\..\nrf5_sdk\components\toolchain; ..\..\..\nrf5_sdk\components\libraries\strerror; ..\..\..\nrf5_sdk\components\libraries\bsp; ..\..\..\nrf5_sdk\components\boards
  ICCARM.CCOptLevel: 3
  group ANT_BLAZE
    ../../../bin/: ANT_BLAZE_Gateway_Library_IAR.a
  group Application
    ../src/: main.c
  group Board Support
    ../../../nrf5_sdk/components/boards/: boards.c
    ../../../nrf5_sdk/components/libraries/bsp/: bsp.c
  group CMSIS
    ../../../nrf5_sdk/components/toolchain/iar/: iar_startup_nrf52.s
    ../../../nrf5_sdk/components/toolchain/: system_nrf52.c
  group nRF_ANT
    ../../../nrf5_sdk/components/ant/ant_stack_config/: ant_stack_config.c
  group nRF_Drivers
    ../../../nrf5_sdk/components/drivers_nrf/common/: nrf_drv_common.c
    ../../../nrf5_sdk/components/drivers_nrf/gpiote/: nrf_drv_gpiote.c
  group nRF_Libraries
    ../../../nrf5_sdk/components/libraries/button/: app_button.c
    ../../../nrf5_sdk/components/libraries/util/: app_error.c app_error_weak.c app_util_platform.c nrf_assert.c
    ../../../nrf5_sdk/components/libraries/timer/: app_timer.c
    ../../../nrf5_sdk/components/libraries/hardfault/nrf52/handler/: hardfault_handler_iar.c
    ../../../nrf5_sdk/components/libraries/hardfault/: hardfault_implementation.c
  group nRF_Log
    ../../../nrf5_sdk/components/libraries/log/src/: nrf_log_backend_serial.c nrf_log_frontend.c
    ../../../nrf5_sdk/external/segger_rtt/: RTT_Syscalls_IAR.c SEGGER_RTT.c SEGGER_RTT_printf.c
