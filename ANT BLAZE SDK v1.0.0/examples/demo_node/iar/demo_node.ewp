# IAR project demo_node.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: nrf52832_xxaa nRF52832_xxAA
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: ANT_STACK_SUPPORT_REQD; NRF52832; S332; BOARD_CUSTOM; NRF52; SOFTDEVICE_PRESENT; SWI_DISABLE0
  ICCARM.CCDiagSuppress: pa050
  ICCARM.CCIncludePath2: ..\inc; ..\config; ..\..\..\inc; ..\..\..\nrf5_sdk\components\ant\ant_stack_config; ..\..\..\nrf5_sdk\components\drivers_nrf\common; ..\..\..\nrf5_sdk\components\drivers_nrf\config; ..\..\..\nrf5_sdk\components\drivers_nrf\delay; ..\..\..\nrf5_sdk\components\drivers_nrf\gpiote; ..\..\..\nrf5_sdk\components\drivers_nrf\hal; ..\..\..\nrf5_sdk\components\libraries\button; ..\..\..\nrf5_sdk\components\libraries\scheduler; ..\..\..\nrf5_sdk\components\libraries\timer; ..\..\..\nrf5_sdk\components\libraries\util; ..\..\..\nrf5_sdk\components\softdevice\common\softdevice_handler; ..\..\..\nrf5_sdk\components\softdevice\s332\headers; ..\..\..\nrf5_sdk\components\softdevice\s332\headers\nrf52; ..\..\..\nrf5_sdk\components\toolchain; ..\..\..\nrf5_sdk\examples\bsp; ..\..\..\nrf5_sdk\components\device; ..\..\..\nrf5_sdk\components\toolchain\CMSIS\Include; ..\..\..\nrf5_sdk\components\libraries\log; ..\..\..\nrf5_sdk\components\libraries\log\src; ..\..\..\nrf5_sdk\external\segger_rtt; ..\..\..\nrf5_sdk\components\boards; ..\..\..\nrf5_sdk\components\libraries\strerror
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: ANT_STACK_SUPPORT_REQD; DEBUG; S212; BOARD_PCA10040; NRF52_PAN_12; NRF52_PAN_15NRF52_PAN_20; NRF52_PAN_30; NRF52_PAN_31; NRF52_PAN_36; NRF52_PAN_51; NRF52_PAN_53; NRF52_PAN_54; NRF52_PAN_55; NRF52_PAN_58; NRF52_PAN_62; NRF52_PAN_63; NRF52_PAN_64; CONFIG_GPIO_AS_PINRESET; NRF52; SOFTDEVICE_PRESENT; SWI_DISABLE0
  OBJCOPY.OOCOutputFile: demo_node.hex
  ILINK.IlinkOutputFile: demo_node.out
  ILINK.IlinkIcfFile: demo_node.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM, debug)
  as the first configuration, except:
  ICCARM.CCIncludePath2: ..\inc; ..\config; ..\..\..\inc; ..\..\..\ant_device_firmware_update\include; ..\..\..\nrf5_sdk\components\ant\ant_stack_config; ..\..\..\nrf5_sdk\components\drivers_nrf\common; ..\..\..\nrf5_sdk\components\drivers_nrf\config; ..\..\..\nrf5_sdk\components\drivers_nrf\delay; ..\..\..\nrf5_sdk\components\drivers_nrf\gpiote; ..\..\..\nrf5_sdk\components\drivers_nrf\hal; ..\..\..\nrf5_sdk\components\libraries\button; ..\..\..\nrf5_sdk\components\libraries\scheduler; ..\..\..\nrf5_sdk\components\libraries\timer; ..\..\..\nrf5_sdk\components\libraries\util; ..\..\..\nrf5_sdk\components\softdevice\common\softdevice_handler; ..\..\..\nrf5_sdk\components\softdevice\s332\headers; ..\..\..\nrf5_sdk\components\softdevice\s332\headers\nrf52; ..\..\..\nrf5_sdk\components\toolchain; ..\..\..\nrf5_sdk\examples\bsp; ..\..\..\nrf5_sdk\components\device; ..\..\..\nrf5_sdk\components\toolchain\CMSIS\Include; ..\..\..\nrf5_sdk\components\libraries\log; ..\..\..\nrf5_sdk\components\libraries\log\src; ..\..\..\nrf5_sdk\external\segger_rtt; ..\..\..\nrf5_sdk\components\boards; ..\..\..\nrf5_sdk\components\libraries\strerror
  OBJCOPY.OOCOutputFile: demo_node.srec
  group (top)
    ../../../nrf5_sdk/components/toolchain/iar/: iar_startup_nrf52.s
    ../../../nrf5_sdk/components/toolchain/: system_nrf52.c
  group ANT_BLAZE
    ../../../bin/: ANT_BLAZE_Node_Library_IAR.a
  group Application
    ../src/: main.c
  group Board Support
    ../../../nrf5_sdk/components/libraries/bsp/: bsp.c
  group nRF_ANT
    ../../../nrf5_sdk/components/ant/ant_channel_config/: ant_channel_config.c
    ../../../nrf5_sdk/components/ant/ant_search_config/: ant_search_config.c
    ../../../nrf5_sdk/components/ant/ant_stack_config/: ant_stack_config.c
  group nRF_Drivers
    ../../../nrf5_sdk/components/drivers_nrf/common/: nrf_drv_common.c
    ../../../nrf5_sdk/components/drivers_nrf/gpiote/: nrf_drv_gpiote.c
  group nRF_Libraries
    ../../../nrf5_sdk/components/libraries/button/: app_button.c
    ../../../nrf5_sdk/components/libraries/util/: app_error.c app_error_weak.c app_util_platform.c nrf_assert.c
    ../../../nrf5_sdk/components/libraries/timer/: app_timer.c
    ../../../nrf5_sdk/components/libraries/hardfault/nrf52/handler/: hardfault_handler_iar.c
    ../../../nrf5_sdk/components/libraries/hardfault/: hardfault_implementation.c
  group nRF_Log
    ../../../nrf5_sdk/components/libraries/log/src/: nrf_log_backend_serial.c nrf_log_frontend.c
    ../../../nrf5_sdk/external/segger_rtt/: RTT_Syscalls_IAR.c SEGGER_RTT.c SEGGER_RTT_printf.c
