# Keil uVision project demo_node.uvprojx, settings and files
target standalone (ARM-ADS)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.12.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(64000000) ELITTLE
  output: demo_node +hex
  c flags: Optim=4 uC99=1
  c define: ANT_STACK_SUPPORT_REQD NRF52832 S332 BOARD_CUSTOM NRF52 SOFTDEVICE_PRESENT SWI_DISABLE0 CONFIG_GPIO_AS_PINRESET
  c misc: --diag_suppress=1296
  c include: ..\inc;..\config;..\..\..\inc;..\..\..\nrf5_sdk\components\ant\ant_channel_config;..\..\..\nrf5_sdk\components\ant\ant_search_config;..\..\..\nrf5_sdk\components\ant\ant_stack_config;..\..\..\nrf5_sdk\components\ble\ble_advertising;..\..\..\nrf5_sdk\components\ble\common;..\..\..\nrf5_sdk\components\drivers_nrf\common;..\..\..\nrf5_sdk\components\drivers_nrf\config;..\..\..\nrf5_sdk\components\drivers_nrf\delay;..\..\..\nrf5_sdk\components\drivers_nrf\gpiote;..\..\..\nrf5_sdk\components\drivers_nrf\hal;..\..\..\nrf5_sdk\components\libraries\button;..\..\..\nrf5_sdk\components\libraries\scheduler;..\..\..\nrf5_sdk\components\libraries\timer;..\..\..\nrf5_sdk\components\libraries\util;..\..\..\nrf5_sdk\components\libraries\fstorage;..\..\..\nrf5_sdk\components\libraries\log;..\..\..\nrf5_sdk\components\libraries\log\src;..\..\..\nrf5_sdk\components\softdevice\common\softdevice_handler;..\..\..\nrf5_sdk\components\toolchain;..\..\..\nrf5_sdk\components\boards;..\..\..\nrf5_sdk\external\segger_rtt;..\..\..\nrf5_sdk\components\softdevice\s332\headers;..\..\..\nrf5_sdk\components\softdevice\s332\headers\nrf52;..\..\..\nrf5_sdk\components\libraries\experimental_section_vars;..\..\..\nrf5_sdk\components\libraries\strerror
  asm define: ANT_STACK_SUPPORT_REQD DEBUG S332 BOARD_CUSTOM NRF52_PAN_12 NRF52_PAN_15 NRF52_PAN_20 NRF52_PAN_30 NRF52_PAN_31 NRF52_PAN_36 NRF52_PAN_51 NRF52_PAN_53 NRF52_PAN_54 NRF52_PAN_55 NRF52_PAN_58 NRF52_PAN_62 NRF52_PAN_63 NRF52_PAN_64 CONFIG_GPIO_AS_PINRESET NRF52 SOFTDEVICE_PRESENT SWI_DISABLE0
  asm misc: --cpreproc
  memory RVCT4: ROM 0x29000 size 0x57000
  memory RVCT9: RAM 0x20001e30 size 0xe1d0
  group Application
    ../src/: main.c
  group Documentation
    ../../../: license.txt
  group ANT_BLAZE
    ../../../bin/: ANT_BLAZE_Node_Library_Keil.lib
  group App_BLE
    ../src/: ble_sf_service.c ble_app_interface.c
  group nRF_ANT
    ../../../nrf5_sdk/components/ant/ant_stack_config/: ant_stack_config.c
  group nRF_BLE
    ../../../nrf5_sdk/components/ble/ble_advertising/: ble_advertising.c
    ../../../nrf5_sdk/components/ble/common/: ble_advdata.c ble_srv_common.c ble_conn_params.c
  group nRF_Drivers
    ../../../nrf5_sdk/components/drivers_nrf/common/: nrf_drv_common.c
    ../../../nrf5_sdk/components/drivers_nrf/gpiote/: nrf_drv_gpiote.c
  group nRF_Libraries
    ../../../nrf5_sdk/components/libraries/util/: app_error.c nrf_assert.c app_error_weak.c app_util_platform.c
    ../../../nrf5_sdk/components/libraries/timer/: app_timer.c
    ../../../nrf5_sdk/components/libraries/hardfault/nrf52/handler/: hardfault_handler_keil.c
    ../../../nrf5_sdk/components/libraries/hardfault/: hardfault_implementation.c
    ../../../nrf5_sdk/components/libraries/fstorage/: fstorage.c
  group nRF_Log
    ../../../nrf5_sdk/components/libraries/log/src/: nrf_log_backend_serial.c nrf_log_frontend.c
    ../../../nrf5_sdk/external/segger_rtt/: RTT_Syscalls_KEIL.c SEGGER_RTT.c SEGGER_RTT_printf.c
target standalone_BLE (ARM-ADS)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.12.0
  cpu: as above
  output: ant_sf_demo_standalone_ble +hex
  c flags: Optim=2 uC99=1
  c define: STANDALONE ANT_STACK_SUPPORT_REQD BLE_STACK_SUPPORT_REQD NRF52832 S332 BOARD_CUSTOM NRF52 SOFTDEVICE_PRESENT SWI_DISABLE0 NRF_SD_BLE_API_VERSION=4 CONFIG_GPIO_AS_PINRESET DEBUG
  c misc: --diag_suppress=1296
  c include: ..\inc;..\config;..\..\..\inc;..\..\..\ant_device_firmware_update\include;..\..\..\nrf5_sdk\components\ant\ant_channel_config;..\..\..\nrf5_sdk\components\ant\ant_search_config;..\..\..\nrf5_sdk\components\ant\ant_stack_config;..\..\..\nrf5_sdk\components\ble\ble_advertising;..\..\..\nrf5_sdk\components\ble\common;..\..\..\nrf5_sdk\components\drivers_nrf\common;..\..\..\nrf5_sdk\components\drivers_nrf\config;..\..\..\nrf5_sdk\components\drivers_nrf\delay;..\..\..\nrf5_sdk\components\drivers_nrf\gpiote;..\..\..\nrf5_sdk\components\drivers_nrf\hal;..\..\..\nrf5_sdk\components\libraries\button;..\..\..\nrf5_sdk\components\libraries\scheduler;..\..\..\nrf5_sdk\components\libraries\timer;..\..\..\nrf5_sdk\components\libraries\util;..\..\..\nrf5_sdk\components\libraries\fstorage;..\..\..\nrf5_sdk\components\libraries\log;..\..\..\nrf5_sdk\components\libraries\log\src;..\..\..\nrf5_sdk\components\softdevice\common\softdevice_handler;..\..\..\nrf5_sdk\components\toolchain;..\..\..\nrf5_sdk\components\boards;..\..\..\nrf5_sdk\external\segger_rtt;..\..\..\nrf5_sdk\components\softdevice\s332\headers;..\..\..\nrf5_sdk\components\softdevice\s332\headers\nrf52;..\..\..\nrf5_sdk\components\libraries\experimental_section_vars;..\..\..\nrf5_sdk\components\libraries\strerror
  asm define: ANT_STACK_SUPPORT_REQD DEBUG S212 BOARD_PCA10040 NRF52_PAN_12 NRF52_PAN_15 NRF52_PAN_20 NRF52_PAN_30 NRF52_PAN_31 NRF52_PAN_36 NRF52_PAN_51 NRF52_PAN_53 NRF52_PAN_54 NRF52_PAN_55 NRF52_PAN_58 NRF52_PAN_62 NRF52_PAN_63 NRF52_PAN_64 CONFIG_GPIO_AS_PINRESET NRF52 SOFTDEVICE_PRESENT SWI_DISABLE0
  asm misc: --cpreproc
  memory RVCT4: ROM 0x29000 size 0x57000
  memory RVCT9: RAM 0x20004000 size 0xc000
software components: CMSIS:CORE 4.3.0, Device:Startup 8.5.0
